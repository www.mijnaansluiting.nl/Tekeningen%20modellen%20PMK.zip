Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 07316ef5-d975-4429-8b24-6951ed522330, NumberOfSaves: 8]
File name: Project Number
Time: 2023-11-06T15:45:09+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.20.70 - Exporter 23.2.5.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Prefab meterkast:Prefab meterkast, Prefab meterkast:Prefab meterkast:235282
In: Level 1
Type - Material: Afwerking Zwart, Afwerking wit, Afwerking Grijs, Afwerking hout
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Prefab meterkast; sets with these values: 2
Pset_ProvisionForVoid - Width: 844 mm; Height: 20 mm; Depth: 20 mm
